# Autodesk Inventor assembly: TOP
## iProperties
Created: 2007-08
Part Number: TOP
Document SubType Name: Assembly
Designer: t-ikumi
Author: t-ikumi
